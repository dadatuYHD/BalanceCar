# Keil uVision project Minibalance.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Minibalance +hex
  c flags: Optim=1
  c define: STM32F10X_MD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\usart3;..\HARDWARE\ADC;..\HARDWARE\TIMER;..\HARDWARE\MOTOR;..\BALANCE\CONTROL;..\HARDWARE\ENCODER;..\HARDWARE\IIC;..\BALANCE\CONTROL;..\BALANCE\DMP;..\BALANCE\filter;..\BALANCE\MPU6050;..\BALANCE\show;..\BALANCE\controls;..\HARDWARE\PROTOCOL;..\HARDWARE\BEEP;..\HARDWARE\Exit;..\HARDWARE\Landzo_CCD
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_md.s
  group USER
    ./: Minibalance.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: LED.C
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/usart3/: usart3.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/IIC/: IOI2C.c
    ../HARDWARE/BEEP/: Beep.c
    ../HARDWARE/Exit/: Exit.c
    ../HARDWARE/Landzo_CCD/: Landzo_CCD.C
  group BALANCE
    ../BALANCE/CONTROL/: control.c
    ../BALANCE/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../BALANCE/filter/: filter.c
    ../BALANCE/MPU6050/: MPU6050.c
    ../BALANCE/show/: show.c
  group PROTOCOL
    ../HARDWARE/PROTOCOL/: Protocol.c Protocol2.c
